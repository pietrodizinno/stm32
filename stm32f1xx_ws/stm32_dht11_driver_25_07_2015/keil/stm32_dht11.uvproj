# Keil uVision project stm32_dht11.uvproj, settings and files
target stm32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: stm32_dht11
  c flags: Optim=1
  c define: STM32F10X_HD __ASSERT_MSG
  c include: ..\stm32;..\libraries\CMSIS\CM3\CoreSupport;..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\gpio;..\usart;..\timer;..\dht11
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group stm32
    ../stm32/: stm32f10x_conf.h system_stm32f10x.c
  group libraries
    ../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h
  group source
    ../main/: main.c
  group gpio
    ../gpio/: gpio.c gpio.h
  group usart
    ../usart/: usart.c usart.h
  group tim2
    ../timer/: timer.c timer.h
  group dht11
    ../dht11/: dht11.c dht11.h
  group retarget
    ../retarget/: retarget.c
